# Keil uVision project ETree.uvprojx, settings and files
target ETree (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ETree +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\Libs\CMSIS\Include;..\Libs\CMSIS\Device\ST\STM32F4xx\Include;..\Libs\STM32F4xx_StdPeriph_Driver\inc;..\Libs\STM32F4x7_ETH_Driver\inc;..\Libs\FreeRTOSv202112.00\FreeRTOS\Source\include;..\Libs\FreeRTOSv202112.00\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Libs\lwip-2.1.3\src\include;..\Libs\lwip-2.1.3\port\STM32F4x7;..\Libs\lwip-2.1.3\port\STM32F4x7\Standalone;..\Bsp;..\Drv;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx_StdPeriph_Driver
    ../Libs/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4x7_ETH_Driver
    ../Libs/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIP
    ../Libs/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Libs/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Libs/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Libs/lwip-2.1.3/src/netif/: ethernet.c
  group FreeRTOS
    ../Libs/FreeRTOSv202112.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Libs/FreeRTOSv202112.00/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Bsp
    ../Bsp/: Uart.c Eth.c Tim.c
  group Drv
    ../Drv/: Delay.c Led.c Ip101gr.c Malloc.c Log.c RingBuf.c Heap.c SysTick.c
  group User
    ../User/: startup_stm32f40xx.s system_stm32f4xx.c stm32f4xx_it.c FreeRTOSConfig.h lwipopts.h netconf.c main.c tcpecho_raw.c
    ../Libs/lwip-2.1.3/port/STM32F4x7/Standalone/: ethernetif.c
